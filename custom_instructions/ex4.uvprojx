# Keil uVision project ex4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4072FBD80 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IRAM(0x10000000,0x4000) IRAM2(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ex4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, CMSIS:NN Lib 1.2.0, Device:Startup 1.0.1
